# IAR project dsp_pdm_sai_cm33.ewp, settings and files
configuration flash_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMX8UD7_M33 NXP MIMX8UD7_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; ENABLE_RAM_VECTOR_TABLE; CPU_MIMX8UD7DVP10_cm33; DSP_IMAGE_COPY_TO_RAM=1; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8960_ENABLE; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../devices/MIMX8UD7/drivers; ../../../../../../devices/MIMX8UD7/utilities/str; ../../../../../../devices/MIMX8UD7/utilities/debug_console_lite; ../../../../../../components/codec/wm8960; ../../../../../../components/codec; ../../../../../../components/codec/port/wm8960; ../../../../../../components/codec/port; ../../../../../../components/codec/i2c; ../../../../../../components/i2c; ../../../../../../devices/MIMX8UD7; ../../../../../../components/uart; ../../../../../../components/lists; ../../../../../../devices/MIMX8UD7/drivers/upower; ../../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; DSP_IMAGE_COPY_TO_RAM=1; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ../../dsp/binary
  OBJCOPY.OOCOutputFile: sdk20-app.bin
  ILINK.IlinkOutputFile: dsp_pdm_sai_cm33.out
  ILINK.IlinkIcfFile: MIMX8UD7xxxxx_cm33_flash.icf
  ILINK.IlinkExtraOptions: --image_input=../../dsp/binary/dsp_reset_release.bin,__dsp_reset_bin,__dsp_reset_section,4; --keep=__dsp_reset_bin; --image_input=../../dsp/binary/dsp_text_release.bin,__dsp_text_bin,__dsp_text_section,4; --keep=__dsp_text_bin; --image_input=../../dsp/binary/dsp_data_release.bin,__dsp_data_bin,__dsp_data_section,4; --keep=__dsp_data_bin
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; ENABLE_RAM_VECTOR_TABLE; CPU_MIMX8UD7DVP10_cm33; NDEBUG; DSP_IMAGE_COPY_TO_RAM=1; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_CODEC=1; CODEC_WM8960_ENABLE; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: DSP_IMAGE_COPY_TO_RAM=1; __STARTUP_INITIALIZE_NONCACHEDATA
  group dsp_binary
    ../../dsp/binary/: dsp_reset_release.bin dsp_text_release.bin dsp_data_release.bin
  group source
    ../: main_cm33.c dsp_config.h
  group board
    ../: pin_mux.c pin_mux.h dsp_support.c dsp_support.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group remoteproc
    ../: empty_rsc_table.c
  group drivers
    ../../../../../../devices/MIMX8UD7/drivers/: fsl_fusion.h fsl_fusion.c fsl_lpi2c.c fsl_lpi2c.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_clock.h fsl_clock.c fsl_reset.h fsl_reset.c fsl_flexspi.c fsl_flexspi.h fsl_lpuart.h fsl_lpuart.c fsl_cache.c fsl_cache.h fsl_iomuxc.h fsl_upower.h fsl_upower.c fsl_rgpio.h fsl_rgpio.c fsl_trdc.h fsl_trdc.c fsl_sentinel.h fsl_sentinel.c fsl_mu.h fsl_mu.c
  group drivers/upower
    ../../../../../../devices/MIMX8UD7/drivers/upower/: upmu.h upower_api.c upower_api.h upower_defs.h upower_soc_defs.h
  group utilities
    ../../../../../../devices/MIMX8UD7/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMX8UD7/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group codec
    ../../../../../../components/codec/wm8960/: fsl_wm8960.h fsl_wm8960.c
    ../../../../../../components/codec/: fsl_codec_common.h fsl_codec_common.c
    ../../../../../../components/codec/i2c/: fsl_codec_i2c.h fsl_codec_i2c.c
  group codec/port
    ../../../../../../components/codec/port/: fsl_codec_adapter.h
  group codec/port/wm8960
    ../../../../../../components/codec/port/wm8960/: fsl_codec_wm8960_adapter.c fsl_codec_wm8960_adapter.h
  group component/i2c
    ../../../../../../components/i2c/: fsl_adapter_i2c.h fsl_adapter_lpi2c.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group device
    ../../../../../../devices/MIMX8UD7/: fsl_device_registers.h MIMX8UD7_cm33.h MIMX8UD7_cm33_features.h system_MIMX8UD7_cm33.c system_MIMX8UD7_cm33.h
  group startup
    ../../../../../../devices/MIMX8UD7/iar/: startup_MIMX8UD7_cm33.s
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
