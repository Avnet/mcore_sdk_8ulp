# IAR project flexcan_pretended_networking_wakeup.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMX8UD7_M33 NXP MIMX8UD7_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CPU_MIMX8UD7DVP10_cm33; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_PCA6416A=1; FLEXCAN_WAIT_TIMEOUT=1000; PRINTF_ADVANCED_ENABLE=1; MCUXPRESSO_SDK
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..; ../../../../../../devices/MIMX8UD7/utilities/str; ../../../../../../devices/MIMX8UD7/utilities/debug_console_lite; ../../../../../../components/pca6416a; ../../../../../../devices/MIMX8UD7/drivers; ../../../../../../devices/MIMX8UD7; ../../../../../../components/uart; ../../../../../../components/lists; ../../../../../../devices/MIMX8UD7/drivers/upower; ../../../../../../CMSIS/Core/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  OBJCOPY.OOCOutputFile: sdk20-app.bin
  ILINK.IlinkOutputFile: flexcan_pretended_networking_wakeup.out
  ILINK.IlinkIcfFile: MIMX8UD7xxxxx_cm33_ram.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration flash_debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; ENABLE_RAM_VECTOR_TABLE; CPU_MIMX8UD7DVP10_cm33; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_PCA6416A=1; FLEXCAN_WAIT_TIMEOUT=1000; PRINTF_ADVANCED_ENABLE=1; MCUXPRESSO_SDK
  ILINK.IlinkIcfFile: MIMX8UD7xxxxx_cm33_flash.icf
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMX8UD7DVP10_cm33; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_PCA6416A=1; FLEXCAN_WAIT_TIMEOUT=1000; PRINTF_ADVANCED_ENABLE=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
configuration flash_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; ENABLE_RAM_VECTOR_TABLE; CPU_MIMX8UD7DVP10_cm33; NDEBUG; SDK_I2C_BASED_COMPONENT_USED=1; BOARD_USE_PCA6416A=1; FLEXCAN_WAIT_TIMEOUT=1000; PRINTF_ADVANCED_ENABLE=1; MCUXPRESSO_SDK
  ICCARM.CCOptLevel: 3
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  ILINK.IlinkIcfFile: MIMX8UD7xxxxx_cm33_flash.icf
  group source
    ../: flexcan_pretended_networking_wakeup.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.txt
  group remoteproc
    ../: empty_rsc_table.c
  group utilities
    ../../../../../../devices/MIMX8UD7/utilities/str/: fsl_str.c fsl_str.h
    ../../../../../../devices/MIMX8UD7/utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h fsl_assert.c
  group components/pca6416a
    ../../../../../../components/pca6416a/: fsl_pca6416a.h fsl_pca6416a.c
  group drivers
    ../../../../../../devices/MIMX8UD7/drivers/: fsl_lpi2c.c fsl_lpi2c.h fsl_flexcan.h fsl_flexcan.c fsl_clock.h fsl_clock.c fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_flexspi.c fsl_flexspi.h fsl_lpuart.h fsl_lpuart.c fsl_cache.c fsl_cache.h fsl_iomuxc.h fsl_reset.h fsl_reset.c fsl_upower.h fsl_upower.c fsl_rgpio.h fsl_rgpio.c fsl_fusion.h fsl_fusion.c fsl_trdc.h fsl_trdc.c fsl_sentinel.h fsl_sentinel.c fsl_mu.h fsl_mu.c
  group drivers/upower
    ../../../../../../devices/MIMX8UD7/drivers/upower/: upmu.h upower_api.c upower_api.h upower_defs.h upower_soc_defs.h
  group device
    ../../../../../../devices/MIMX8UD7/: fsl_device_registers.h MIMX8UD7_cm33.h MIMX8UD7_cm33_features.h system_MIMX8UD7_cm33.c system_MIMX8UD7_cm33.h
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group startup
    ../../../../../../devices/MIMX8UD7/iar/: startup_MIMX8UD7_cm33.s
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_iccarm.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
